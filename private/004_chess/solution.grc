options:
  parameters:
    generate_options: qt_gui
    id: solution
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: dec
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(250e3)
  states: {}
- name: ais_rx_core_0
  id: ais_rx_core
  parameters:
    bb_sps: '4'
    bt: '0.4'
    loopbw: '0.05'
    samp_rate: 250e3
    threshold: '0.83'
  states: {}
- name: ais_rx_core_0_0
  id: ais_rx_core
  parameters:
    bb_sps: '4'
    bt: '0.4'
    loopbw: '0.05'
    samp_rate: 250e3
    threshold: '0.83'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      Direct baseband to audio sink. 
      Gives instructions for how to solve the puzzle:
      "White to move, mate in 1"
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: 25e3
    sample_rate: 250e3
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-25e3'
    sample_rate: 250e3
  states: {}
- name: blocks_sigmf_source_minimal_0
  id: blocks_sigmf_source_minimal
  parameters:
    file: /home/bb32642/projects/grcon23/private/004_chess/symphony.sigmf-data
    repeat: 'False'
    type: complex float (fc32_le)
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 48e3
    type: float
  states: {state: bypassed}
- name: blocks_throttle_comp
  id: blocks_throttle
  parameters:
    samples_per_second: 250e3
    type: complex
  states: {}
- name: blocks_throttle_comp_0
  id: blocks_throttle
  parameters:
    samples_per_second: 250e3
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_BLACKMAN
  states: {}
- name: pdu_to_nmea_0
  id: pdu_to_nmea
  parameters:
    comment: Channel A = The white pieces.
    designator: A
  states: {}
- name: pdu_to_nmea_0_0
  id: pdu_to_nmea
  parameters:
    comment: Channel B = The black pieces.
    designator: B
  states: {}

connections:
- [ais_rx_core_0, out, pdu_to_nmea_0, print]
- [ais_rx_core_0, out, pdu_to_nmea_0, to_nmea]
- [ais_rx_core_0_0, out, pdu_to_nmea_0_0, print]
- [ais_rx_core_0_0, out, pdu_to_nmea_0_0, to_nmea]
- [blocks_complex_to_float_0, '0', blocks_throttle_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_throttle_comp, '0']
- [blocks_freqshift_cc_0_0, '0', blocks_throttle_comp_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_sigmf_source_minimal_0, '0', blocks_freqshift_cc_0_0, '0']
- [blocks_sigmf_source_minimal_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', audio_sink_0, '0']
- [blocks_throttle_comp, '0', ais_rx_core_0, '0']
- [blocks_throttle_comp_0, '0', ais_rx_core_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
