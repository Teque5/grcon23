options:
  parameters:
    author: K6OF
    generate_options: qt_gui
    id: scramble_descrable
    output_language: python
    title: Scramble & Descramble
  states: {}

blocks:
- name: agc_probe
  id: variable_function_probe
  parameters:
    block_id: analog_agc2_xx_0
    function_name: gain
    poll_rate: '10'
    value: '0'
  states: {}
- name: enable_noise
  id: variable_qtgui_chooser
  parameters:
    label: Select Waveform
    label0: Tone
    label1: Noise
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '1'
  states: {}
- name: fc_internal
  id: variable
  parameters:
    comment: used to offset fc
    value: (fc_khz-sweep_bw_khz/2)
  states: {}
- name: fc_khz
  id: variable_qtgui_range
  parameters:
    label: fc_khz
    start: '-10'
    step: '.1'
    stop: '10'
    value: '3'
  states: {}
- name: hops_per_second
  id: variable
  parameters:
    comment: Ideally integer divides samp_rate
    value: '9'
  states: {}
- name: noise_bw_khz
  id: variable_qtgui_range
  parameters:
    label: noise_bw_khz
    start: '0'
    step: '.001'
    stop: '10'
    value: '.2'
  states: {}
- name: peak_volume
  id: variable
  parameters:
    comment: '-8 LUFS'
    value: 10**(-8/10)
  states: {}
- name: probe_freq_shift
  id: variable_function_probe
  parameters:
    block_id: siggen_jumper
    function_args: fc_internal*1e3+(random.random()*2-1)*var_khz*1e3
    function_name: set_frequency
    poll_rate: '.2'
    value: fc_internal*1e3
  states: {state: disabled}
- name: probe_freq_shift_0
  id: variable_function_probe
  parameters:
    block_id: siggen_jumper
    function_args: (random.random()*2*3.1415926535)
    function_name: set_phase
    poll_rate: '1'
    value: '1'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: secret
  id: variable
  parameters:
    value: b'thequickbrownfoxjumpsoverthelazydogjackdawslovemybigsphinxofquartz'
  states: {}
- name: sweep_bw_khz
  id: variable_qtgui_range
  parameters:
    label: sweep_bw_khz
    start: '0'
    step: '.001'
    stop: samp_rate/2/1e3
    value: '6'
  states: {}
- name: sweep_rate
  id: variable_qtgui_range
  parameters:
    label: sweep_rate
    start: '0'
    step: '.1'
    stop: '100'
    value: '.1'
  states: {}
- name: var_khz
  id: variable
  parameters:
    value: (fc_khz-sweep_bw_khz/2)
  states: {state: disabled}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    label: agc_level
    type: int
    value: agc_probe
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: peak_volume
    type: complex
  states: {}
- name: analog_agc2_xx_1
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '.25'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: analog_frequency_modulator_fc_1
  id: analog_frequency_modulator_fc
  parameters:
    comment: f_dev=fmax-fmin
    sensitivity: (2*3.1415926535*sweep_bw_khz*1e3)/samp_rate
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1024'
    repeat: 'True'
    type: int
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: tone source
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: freq=sweep_rate
    freq: sweep_rate
    offset: '0'
    phase: '0'
    samp_rate: samp_rate*16
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: fmin
    freq: (fc_khz+sweep_bw_khz/2)*1e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '64'
    type: float
  states: {state: disabled}
- name: blocks_integrate_xx_1
  id: blocks_integrate_xx
  parameters:
    decim: '16'
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: '1e-4'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: '1e-4'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/16
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: int(samp_rate/hops_per_second)
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: enable_noise
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '64'
    type: float
  states: {state: disabled}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {state: bypassed}
- name: blocks_throttle_0_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: '10'
    type: float
  states: {state: disabled}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Secret should be ascii from 0x61 (a) to 0x7a (z).
    repeat: 'True'
    type: float
    vector: ((np.frombuffer(secret, dtype=np.uint8) -0x61) / (0x7a-0x61))-1
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/kal29868/Projects/grcon23/private/003_scramble/scramble1.wav
    repeat: 'True'
  states: {}
- name: digital_glfsr_source_x_0
  id: digital_glfsr_source_x
  parameters:
    comment: produces +- 1 only
    degree: '16'
    mask: '0'
    repeat: 'True'
    seed: '1'
    type: float
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: low_pass_filter_0_1
  id: low_pass_filter
  parameters:
    cutoff_freq: noise_bw_khz*1e3/2
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '50'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    comment: check for unit power out
    graph_type: qtgui.NUM_GRAPH_NONE
    name: power
    type: float
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    comment: check for unit power out
    graph_type: qtgui.NUM_GRAPH_NONE
    name: power
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1_1
  id: qtgui_number_sink
  parameters:
    comment: check for unit power out
    graph_type: qtgui.NUM_GRAPH_NONE
    name: resampled
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '.05'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '.05'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_1_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*4
    freqhalf: 'False'
    type: complex
    update_time: '.05'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: int(samp_rate/5)
    type: fff
  states: {state: disabled}
- name: siggen_jumper
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: freq=sweep_rate
    freq: sweep_rate
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {state: disabled}

connections:
- [analog_agc2_xx_0, '0', blocks_complex_to_float_0, '0']
- [analog_agc2_xx_0, '0', blocks_throttle_0_0_0, '0']
- [analog_agc2_xx_0, '0', blocks_throttle_1, '0']
- [analog_agc2_xx_1, '0', audio_sink_0, '0']
- [analog_agc2_xx_1, '0', qtgui_time_sink_x_0_0, '0']
- [analog_const_source_x_0, '0', rational_resampler_xxx_0, '0']
- [analog_frequency_modulator_fc_1, '0', blocks_multiply_xx_0_2, '0']
- [analog_noise_source_x_0_0, '0', low_pass_filter_0_1, '0']
- [analog_random_source_x_0, '0', blocks_int_to_float_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_selector_0, '1']
- [analog_sig_source_x_0_1, '0', analog_frequency_modulator_fc_1, '0']
- [analog_sig_source_x_1_1, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', analog_agc2_xx_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0_2, '1']
- [blocks_int_to_float_0, '0', blocks_integrate_xx_0, '0']
- [blocks_int_to_float_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_int_to_float_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_integrate_xx_0, '0', analog_frequency_modulator_fc_1, '0']
- [blocks_integrate_xx_0, '0', qtgui_number_sink_1, '0']
- [blocks_integrate_xx_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_1, '0']
- [blocks_moving_average_xx_0_0, '0', analog_frequency_modulator_fc_1, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_xx_0_0_0, '0', analog_agc2_xx_0, '0']
- [blocks_multiply_xx_0_2, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_1, '0']
- [blocks_repeat_0, '0', qtgui_number_sink_1_1, '0']
- [blocks_selector_0, '0', blocks_multiply_xx_0_2, '1']
- [blocks_stream_to_vector_0, '0', blocks_integrate_xx_0, '0']
- [blocks_throttle_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0_0_0, '0', qtgui_waterfall_sink_x_1_1, '0']
- [blocks_throttle_0_0_0_0, '0', qtgui_number_sink_1_0, '0']
- [blocks_throttle_1, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [blocks_vector_source_x_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [digital_glfsr_source_x_0, '0', blocks_integrate_xx_1, '0']
- [digital_glfsr_source_x_0, '0', blocks_throttle_0_0_0_0, '0']
- [low_pass_filter_0_1, '0', blocks_selector_0, '0']
- [rational_resampler_xxx_0, '0', analog_frequency_modulator_fc_1, '0']
- [rational_resampler_xxx_0, '0', qtgui_number_sink_1_1, '0']
- [siggen_jumper, '0', analog_frequency_modulator_fc_1, '0']

metadata:
  file_format: 1
